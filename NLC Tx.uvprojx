# Keil uVision project NLC Tx.uvprojx, settings and files
target TM4C123GXL (5060061::V5.06 update 1 (build 61)::ARMCC)
  device: TM4C123GH6PM Texas Instruments
  pack: Keil.TM4C_DFP.1.0.0
  cpu: IROM(0x00000000,0x040000) IRAM(0x20000000,0x008000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: NLC_Tx +hex
  c flags: Optim=1 OneElfS=1 uC99=1 wLevel=2
  c define: PART_TM4C123GH6PM
  c include: C:\ti\TivaWare_C_Series-2.1.1.71
  memory RVCT4: ROM 0x0 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0x8000
  group Main
    ./Source/: main.c
  group Driver
    ./Source/Driver/: mcp4725.c i2c.c
  group System
    ./Source/System/: timer.c uart.c
  group Tiva Ware
    C:/ti/TivaWare_C_Series-2.1.1.71/driverlib/: adc.c aes.c can.c comp.c cpu.c crc.c des.c eeprom.c emac.c epi.c flash.c fpu.c gpio.c hibernate.c i2c.c interrupt.c lcd.c mpu.c onewire.c pwm.c qei.c shamd5.c ssi.c sw_crc.c sysctl.c sysexc.c systick.c timer.c uart.c udma.c usb.c watchdog.c
software components: CMSIS:CORE 4.3.0, Device:Startup 1.0.0
